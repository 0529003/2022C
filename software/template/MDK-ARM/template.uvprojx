# Keil uVision project template.uvprojx, settings and files
target template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: template +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User;../User/LED;../User/APP;../User/PWM;../User/KEY;../User/USART;../User/OLED;../User/YunTai;../../../../../School_electric_match/car_following_system-master/car_following_system-master/stm32/Users/Components/motor;../../../../../School_electric_match/car_following_system-master/car_following_system-master/stm32/Users/Components/encoder;../User/Buzzer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group USER
    ../User/APP/: app.c
    ../User/LED/: led.c
    ../User/PWM/: pwm.c
    ../User/KEY/: key.c
    ../User/USART/: uart_1.c uart_2.c uart_it_config.c
    ../User/OLED/: oled.c
    ../User/YunTai/: yuntai.c
    ../../../../../School_electric_match/car_following_system-master/car_following_system-master/stm32/Users/Components/motor/: motor.c
    ../../../../../School_electric_match/car_following_system-master/car_following_system-master/stm32/Users/Components/encoder/: encoder.c
    ../User/Buzzer/: Buzzer.c
software components: CMSIS:CORE 4.3.0
