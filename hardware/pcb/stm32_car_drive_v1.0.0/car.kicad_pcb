# Repository 0529003/2022C

## KiCad design hardware/pcb/stm32_car_drive_v1.0.0/car.kicad_pcb

Parts:
BZ2: Buzzer; Indicator_PUI_AI-1440-TWT-24V-2-R
C3: 0.1uF; C_0603_1608Metric
D2, D3, D4, D5, D6, D7: LED; LED_0805_2012Metric
H5, H6, H7, H8: MountingHole_Pad_MP; MountingHole_3.2mm_M3
HC-SR04: HC-SR04; PinSocket_1x04_P2.54mm_Vertical
J0: OLED; PinSocket_1x04_P2.54mm_Vertical
J3, J25: HC-05; PinSocket_1x06_P2.54mm_Vertical
J14: I2C; PinSocket_1x04_P2.54mm_Vertical
J15: Conn_01x02; HDR-TH_2P-P2.00-V-F-1
J17: Conn_01x05; PinSocket_1x05_P2.54mm_Vertical
J18, J19, J24: Conn_01x02; PinSocket_1x02_P2.54mm_Vertical
J20: Conn_01x09; PinSocket_1x09_P2.54mm_Vertical
J22: Conn_01x10; JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical
J26: Conn_01x08; PinHeader_1x06_P2.54mm_Vertical
K210: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
P1: USB_C_Plug_USB2.0; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
Q1: S8050; SOT-23
R5, R6, R7, R8, R10, R11: 10k; R_0603_1608Metric
R9, R13: 5.1K; R_0603_1608Metric
R12: 20; R_0603_1608Metric
SW1: K1; SW_Push_1P1T_NO_6x6mm
SW2: K2; SW_Push_1P1T_NO_6x6mm
SW3: K3; SW_Push_1P1T_NO_6x6mm
SW4: K6; SW_Push_1P1T_NO_6x6mm
SW5: K5; SW_Push_1P1T_NO_6x6mm
SW6: K4; SW_Push_1P1T_NO_6x6mm
U10: CH340C; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+3.3V: C3.2, J0.2, J14.2, R5.2, R6.2, R7.2, R8.2, R10.2, R11.2, R12.2, U10.4 (V3), U10.16 (VCC); also elsewhere on the board
+3V3: SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2
+5V: HC-SR04.4, J3.2, J22.2, J25.2, J26.1, K210.4, P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS); also elsewhere on the board
/PA2: J24.1, K210.1; also elsewhere on the board
/PA3: J24.2, K210.2; also elsewhere on the board
/PA4: J17.1; also elsewhere on the board
/PA5: J17.2; also elsewhere on the board
/PA6: J17.3; also elsewhere on the board
/PA7: J17.4; also elsewhere on the board
/PA8: D3.1 (K); also elsewhere on the board
/PA10: SW1.1; also elsewhere on the board
/PA11: SW2.1, U10.2 (TXD); also elsewhere on the board
/PA12: SW3.1, U10.3 (RXD); also elsewhere on the board
/PA15: J20.7; also elsewhere on the board
/PB0: J22.5; also elsewhere on the board
/PB1: J22.4; also elsewhere on the board
/PB2: J22.3; also elsewhere on the board
/PB3: D4.1 (K); also elsewhere on the board
/PB4: J20.2; also elsewhere on the board
/PB5: J20.3; also elsewhere on the board
/PB6: J18.1; also elsewhere on the board
/PB7: J18.2; also elsewhere on the board
/PB8: J0.3, J14.3, J25.6, J26.3; also elsewhere on the board
/PB9: J0.4, J14.4, J25.5, J26.4; also elsewhere on the board
/PB10: J3.4, J19.1; also elsewhere on the board
/PB11: J3.5, J19.2; also elsewhere on the board
/PB12: HC-SR04.2, Q1.1 (B); also elsewhere on the board
/PB13: SW4.1; also elsewhere on the board
/PB14: HC-SR04.3, SW5.1; also elsewhere on the board
/PB15: SW6.1; also elsewhere on the board
/PC2: J22.8; also elsewhere on the board
/PC3: J22.7; also elsewhere on the board
/PC4: J20.6; also elsewhere on the board
/PC5: J22.6; also elsewhere on the board
/PC6: J20.8; also elsewhere on the board
/PC7: J20.9; also elsewhere on the board
/PC8: J15.1; also elsewhere on the board
/PC9: J15.2; also elsewhere on the board
/PC10: J20.4, J25.3; also elsewhere on the board
/PC11: J20.5, J25.4; also elsewhere on the board
/PC12: D6.1 (K); also elsewhere on the board
/PC13: D7.1 (K); also elsewhere on the board
/PD2: D5.1 (K); also elsewhere on the board
GND: C3.1, D2.1 (K), H5.MP, H6.MP, H7.MP, H8.MP, HC-SR04.1, J0.1, J3.3, J3.6, J14.1, J17.5, J20.1, J22.1, J25.1, J26.2, K210.3, P1.A1 (GND), P1.A12 (GND), P1.B1 (GND), P1.B12 (GND), P1.S1 (SHIELD), Q1.2 (E), R9.2, R13.2, U10.1 (GND); also elsewhere on the board
unnamed: BZ2.2 (+), Q1.3 (C)
unnamed: BZ2.1 (-), R12.1
unnamed: D2.2 (A), R5.1
unnamed: D3.2 (A), R6.1
unnamed: D4.2 (A), R7.1
unnamed: D5.2 (A), R8.1
unnamed: D6.2 (A), R10.1
unnamed: D7.2 (A), R11.1
unnamed: P1.A5 (CC), R9.1
unnamed: P1.A6 (D+), U10.5 (UD+)
unnamed: P1.A7 (D-), U10.6 (UD-)
unnamed: P1.B5 (VCONN), R13.1

Notes on the sheet:
USART3
超声波测距
OLED
USB interface
power
Indicator light
STM32F103RCT6 Minimum System
MPU6050
舵机驱动
TOF250
USART2
HC-05蓝牙模块
多余接口
I2C
八路灰度传感器
ADC
Button * 6
USART1
USART2--K210

Parts:
C1, C2: 100uf; CP_Elec_6.3x7.7
J2, J4: Conn_01x06; JST_XH_S6B-XH-A_1x06_P2.50mm_Horizontal
R1, R2: 0.15R 1206 1WOCP=3.3V/10/0.15R=2.2A; R_1206_3216Metric
U2, U3, U4, U6: SOT-363_SC-70-6
U5, U8: DRV8870DDA; Texas_HTSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.4x3.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

Connections:
+3.3V: J2.2, J4.2, U2.5, U3.5, U4.5, U5.4 (VREF), U6.5, U8.4 (VREF); also elsewhere on the board
+12V: C1.1, C2.1, U5.5 (VM), U8.5 (VM); also elsewhere on the board
/PA0: J4.3; also elsewhere on the board
/PA1: J4.4; also elsewhere on the board
/PA8: U2.1, U6.3; also elsewhere on the board
/PA9: U3.3, U4.1; also elsewhere on the board
/PB4: J2.3; also elsewhere on the board
/PB5: J2.4; also elsewhere on the board
/PC14: U2.6, U6.6; also elsewhere on the board
/PC15: U3.6, U4.6; also elsewhere on the board
/bb68942b/AOUT1: J2.6, U5.6 (OUT1)
/bb68942b/AOUT2: J2.1, U5.8 (OUT2)
/bb68942b/BOUT1: J4.6, U8.6 (OUT1)
/bb68942b/BOUT2: J4.1, U8.8 (OUT2)
GND: C1.2, C2.2, J2.5, J4.5, R1.1, R2.1, U2.2, U2.3, U3.1, U3.2, U4.2, U4.3, U5.1 (GND), U5.9 (GND), U6.1, U6.2, U8.1 (GND), U8.9 (GND); also elsewhere on the board
unnamed: U5.3 (IN1), U6.4
unnamed: U2.4, U5.2 (IN2)
unnamed: R1.2, U5.7 (ISEN)
unnamed: U3.4, U8.3 (IN1)
unnamed: U4.4, U8.2 (IN2)
unnamed: R2.2, U8.7 (ISEN)

Parts:
C4, C11: 4.7uf; C_0603_1608Metric
C5, C23: 220uf; CP_Elec_6.3x7.7
C6: 0.1uf; C_0603_1608Metric
C9, C12: 2.2uF; C_0603_1608Metric
C13: 0.01uf; C_0603_1608Metric
D8: B340; D_SMA
J1: DC母座(大)
J5, J6, J7, J8, J9, J10, J11, J12: Conn_01x03; PinSocket_1x03_P2.54mm_Vertical
J13: Conn_01x02; CONN-TH_2P-P5.08
L2: 22uh; L_Wuerth_HCI-1040
R14: R; R_0603_1608Metric
R18: 3.2k; R_0603_1608Metric
SW8: SW_Push_SPDT; SW_CuK_JS202011CQN_DPDT_Straight
U7: TPS5430DDA; TI_SO-PowerPAD-8_ThermalVias
U11: SGM2212-3.3XKC3G/TR; SOT-223

Connections:
+3.3V: C12.1, J9.1, J9.2, J9.3, J10.1, J10.2, J10.3, U11.2 (VOUT), U11.4 (VOUT); also elsewhere on the board
+5V: C9.1, C23.1, J11.1, J11.2, J11.3, J12.1, J12.2, J12.3, L2.2, R14.1, U11.3 (VIN); also elsewhere on the board
+12V: C4.2, C5.1, C6.2, C11.2, SW8.1 (A), U7.7 (VIN); also elsewhere on the board
GND: C4.1, C5.2, C6.1, C9.2, C11.1, C12.2, C23.2, D8.2 (A), J1.2, J5.1, J5.2, J5.3, J6.1, J6.2, J6.3, J7.1, J7.2, J7.3, J8.1, J8.2, J8.3, J13.2, R18.2, U7.6 (GND), U7.9 (GNDPAD), U11.1 (GND); also elsewhere on the board
unnamed: C13.2, D8.1 (K), L2.1, U7.8 (PH)
unnamed: J1.1, J13.1, SW8.2 (B)
unnamed: C13.1, U7.1 (BOOT)
unnamed: R14.2, R18.1, U7.4 (VSENSE)

Notes on the sheet:
DC5V to DC3.3V
输入滤波
5V电源
电源输入

Parts:
C14, C18, C19, C20, C21, C22: 0.1uf/16V; C_0603_1608Metric
C15: 0.1uF/50V; C_0603_1608Metric
C16, C17: 22pf/16V; C_0603_1608Metric
J23: Conn_01x04; PinSocket_1x04_P2.54mm_Vertical
R15: 10K; R_0603_1608Metric
R16: 1M; R_0805_2012Metric
R17: 10k; R_0805_2012Metric
SW7: RST; SW_SPST_FSMSM
U1: STM32F103RCTx; LQFP-64_10x10mm_P0.5mm
Y1: Crystal_GND24(8M); Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C14.1, C18.1, C19.1, C20.1, C21.1, C22.1, J23.2, R15.2, U1.1 (VBAT), U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD); also elsewhere on the board
/PA0: U1.14 (PA0); also elsewhere on the board
/PA1: U1.15 (PA1); also elsewhere on the board
/PA2: U1.16 (PA2); also elsewhere on the board
/PA3: U1.17 (PA3); also elsewhere on the board
/PA4: U1.20 (PA4); also elsewhere on the board
/PA5: U1.21 (PA5); also elsewhere on the board
/PA6: U1.22 (PA6); also elsewhere on the board
/PA7: U1.23 (PA7); also elsewhere on the board
/PA8: U1.41 (PA8); also elsewhere on the board
/PA9: U1.42 (PA9); also elsewhere on the board
/PA10: U1.43 (PA10); also elsewhere on the board
/PA11: U1.44 (PA11); also elsewhere on the board
/PA12: U1.45 (PA12); also elsewhere on the board
/PA15: U1.50 (PA15); also elsewhere on the board
/PB0: U1.26 (PB0); also elsewhere on the board
/PB1: U1.27 (PB1); also elsewhere on the board
/PB2: U1.28 (PB2); also elsewhere on the board
/PB3: U1.55 (PB3); also elsewhere on the board
/PB4: U1.56 (PB4); also elsewhere on the board
/PB5: U1.57 (PB5); also elsewhere on the board
/PB6: U1.58 (PB6); also elsewhere on the board
/PB7: U1.59 (PB7); also elsewhere on the board
/PB8: U1.61 (PB8); also elsewhere on the board
/PB9: U1.62 (PB9); also elsewhere on the board
/PB10: U1.29 (PB10); also elsewhere on the board
/PB11: U1.30 (PB11); also elsewhere on the board
/PB12: U1.33 (PB12); also elsewhere on the board
/PB13: U1.34 (PB13); also elsewhere on the board
/PB14: U1.35 (PB14); also elsewhere on the board
/PB15: U1.36 (PB15); also elsewhere on the board
/PC0: U1.8 (PC0)
/PC1: U1.9 (PC1)
/PC2: U1.10 (PC2); also elsewhere on the board
/PC3: U1.11 (PC3); also elsewhere on the board
/PC4: U1.24 (PC4); also elsewhere on the board
/PC5: U1.25 (PC5); also elsewhere on the board
/PC6: U1.37 (PC6); also elsewhere on the board
/PC7: U1.38 (PC7); also elsewhere on the board
/PC8: U1.39 (PC8); also elsewhere on the board
/PC9: U1.40 (PC9); also elsewhere on the board
/PC10: U1.51 (PC10); also elsewhere on the board
/PC11: U1.52 (PC11); also elsewhere on the board
/PC12: U1.53 (PC12); also elsewhere on the board
/PC13: U1.2 (PC13); also elsewhere on the board
/PC14: U1.3 (PC14); also elsewhere on the board
/PC15: U1.4 (PC15); also elsewhere on the board
/PD2: U1.54 (PD2); also elsewhere on the board
/stm32f103rct6/BOOT0: R17.2, U1.60 (BOOT0)
/stm32f103rct6/OSC_IN: C16.1, R16.1, U1.5 (PD0), Y1.1
/stm32f103rct6/OSC_OUT: C17.1, R16.2, U1.6 (PD1), Y1.3
/stm32f103rct6/RST: C15.2, R15.1, SW7.2, U1.7 (NRST)
/stm32f103rct6/SWCLK: J23.3, U1.49 (PA14)
/stm32f103rct6/SWDIO: J23.4, U1.46 (PA13)
GND: C14.2, C15.1, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, J23.1, R17.1, SW7.1, U1.12 (VSSA), U1.18 (VSS), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS), Y1.2, Y1.4; also elsewhere on the board

Notes on the sheet:
Filtering
Download mode setting
External high speed clock
Download and debug
reset circuit

Board: 2 copper layers, 79.6 x 83.7 mm, 97 parts (7 on the bottom side), 82 nets.
